# Keil uVision project ZJ_RT_THREAD_Apollo.uvprojx, settings and files
target zj_rtthread_apollo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zj_rtthread_apollo +hex
  AfterMake: fromelf --bin !L --output .\build\zj_rtthread_apollo.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3, RT_USING_ARM_LIBC, AM_PACKAGE_BGA
  c include: ..\applications;..\apollo_startup;..\..\..\AmbiqMicro_SDK\mcu\apollo3;..\..\..\RT_Thread\include;..\..\..\RT_Thread\libcpu\arm\cortex-m4;..\..\..\RT_Thread\libcpu\arm\common;..\..\..\RT_Thread\components\dfs\include;..\..\..\RT_Thread\components\dfs\filesystems\devfs;..\..\..\RT_Thread\components\drivers\include;..\..\..\RT_Thread\components\drivers\include;..\..\..\RT_Thread\components\drivers\include;..\..\..\RT_Thread\components\drivers\include;..\..\..\RT_Thread\components\drivers\spi;..\..\..\RT_Thread\components\drivers\include;..\..\..\RT_Thread\components\drivers\include;..\..\..\RT_Thread\components\finsh;..\..\..\RT_Thread\components\libc\compilers\armlibc;..\..\..\AmbiqMicro_SDK\CMSIS\ARM\Include;..\..\..\AmbiqMicro_SDK\CMSIS\AmbiqMicro\Include;..\..\..\Common\segger_rtt;..\applications\app_event;..\applications\app_init;..\config
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    ../applications/app_init/: app_init.c
    ../applications/app_event/: app_event.c
    ../config/: rtconfig.h
  group startup
    ../apollo_startup/: board.c startup_keil.s
  group apollo_hal
    ../../../AmbiqMicro_SDK/mcu/apollo3/hal/: am_hal_clkgen.c am_hal_debug.c am_hal_cachectrl.c am_hal_pwrctrl.c am_hal_mcuctrl.c am_hal_sysctrl.c am_hal_reset.c am_hal_stimer.c am_hal_ctimer.c am_hal_rtc.c am_hal_interrupt.c am_hal_queue.c am_hal_iom.c am_hal_ios.c am_hal_flash.c am_hal_gpio.c am_hal_uart.c am_hal_adc.c am_hal_pdm.c
    ./../../../AmbiqMicro_SDK/mcu/apollo3/hal/: am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cmdq.c am_hal_itm.c am_hal_mspi.c am_hal_secure_ota.c am_hal_security.c am_hal_systick.c am_hal_tpiu.c am_hal_wdt.c
  group Kernel
    ../../../RT_Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../../RT_Thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../RT_Thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../RT_Thread/components/drivers/serial/: serial.c
    ../../../RT_Thread/components/drivers/src/: dataqueue.c completion.c
  group finsh
    ../../../RT_Thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../../RT_Thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
  group segger_rtt
    ../../../Common/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Device.c
